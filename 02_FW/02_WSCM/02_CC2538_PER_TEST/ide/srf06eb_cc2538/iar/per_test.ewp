# IAR project per_test.ewp, settings and files
configuration CC2538 (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: chip=2538; DEBUG; CC2538_USE_ALTERNATE_INTERRUPT_MAP; BOARD_SMARTRF06EB
  ICCARM.CCIncludePath2: ../../../source\components/utils/; ../../../source\components/common; ../../../source\components/basic_rf; ../../../source\components/targets/interface; ../../../source\components/driverlib/cc2538/inc; ../../../source\components/driverlib/cc2538/source; ../../../source\components/bsp/srf06eb_cc2538/drivers/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: chip=2538
  OBJCOPY.OOCOutputFile: per_test.hex
  ILINK.IlinkOutputFile: per_test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../../../source/apps/per_test/: per_test.c per_test.h per_test_menu.c per_test_menu.h
  group basic_rf
    ../../../source/components/basic_rf/: basic_rf.c basic_rf.h
  group bsp/srf06eb
    ../../../source/components/bsp/srf06eb_cc2538/drivers/source/: bsp.c bsp.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h io_pin_int.c io_pin_int.h lcd_dogm128_6.c lcd_dogm128_6.h lcd_dogm128_6_alphabet.c lcd_srf06eb.c
  group cc2538
    ../../../source/components/devices/cc2538/startup_files/: setup.c startup_iar.c
  group cc2538/driverlib
    ../../../source/components/driverlib/cc2538/source/: cpu.c cpu.h debug.h gpio.c gpio.h gptimer.c gptimer.h interrupt.c interrupt.h ioc.c ioc.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h watchdog.c watchdog.h
  group cc2538/driverlib/inc
    ../../../source/components/driverlib/cc2538/inc/: hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_ssi.h hw_sys_ctrl.h hw_types.h
  group hal
    ../../../source/components/common/: hal_defs.h hal_types.h
    ../../../source/components/targets/srf06eb_soc/: hal_int.c
    ../../../source/components/targets/interface/: hal_int.h hal_rf.h hal_timer_32k.h
    ../../../source/components/devices/cc2538/: hal_rf.c hal_timer_32k.c
  group menu_system
    ../../../source/components/devices/lcd_dogm128_6/: lcd_dogm128_6_ti_logo.c util_menu_driver.c
    ../../../source/components/utils/: util_menu_driver.h util_menu_system.c util_menu_system.h
